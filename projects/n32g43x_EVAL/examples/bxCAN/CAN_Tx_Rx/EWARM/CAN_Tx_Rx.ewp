# IAR project CAN_Tx_Rx.ewp, settings and files
configuration N32G43x (ARM, debug)
  General.OGChipSelectEditMenu: N32G435RB Nations N32G435RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G43X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32g43x_std_periph_driver/inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CAN_Tx_Rx.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_can.c n32g43x_dbg.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_pwr.c n32g43x_rcc.c n32g43x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x_EWARM.s
  group USER
    ../src/: main.c n32G43x_it.c User_Can_Config.c User_LED_Config.c User_Sysclock_Config.c User_Systick_Config.c User_Usart_Config.c
